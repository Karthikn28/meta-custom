FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

require vcu.inc
