FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

require uboot.inc

